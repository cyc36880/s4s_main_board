# Keil uVision project main_board.uvprojx, settings and files
target main_board (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: main_board +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../myCode;../myCode/component/zs_tools
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SYS
    ../myCode/SYS/src/: delay.c
  group component/zs_tools
    ../myCode/component/zs_tools/src/container/src/: cc_array.c cc_array_chain.c cc_array_sort.c cc_array_stack.c cc_binary.c cc_common.c cc_hash_map.c cc_list.c cc_list_map.c cc_list_queue.c cc_list_stack.c cc_mem.c cc_ring.c cc_string_builder.c
    ../myCode/component/zs_tools/src/event/: zst_event.c
    ../myCode/component/zs_tools/src/hal/: zst_hal_tick.c
    ../myCode/component/zs_tools/src/log/: c_log.c
    ../myCode/component/zs_tools/src/misc/tlsf/tlsf/: tlsf.c
    ../myCode/component/zs_tools/src/misc/tlsf/: mm_tlsf.c
    ../myCode/component/zs_tools/src/misc/: zst_mem.c pid.c sha256.c
    ../myCode/component/zs_tools/src/polling_tasks/: polling_task.c
    ../myCode/component/zs_tools/src/run_one/: run_one.c
    ../myCode/component/zs_tools/src/timer/: zst_timer.c
    ../myCode/component/zs_tools/src/: zst_core.c
    ../myCode/component/: zst_conf.h
  group misc
    ../myCode/misc/src/: data_structure.c mtools.c
  group Drive
    ../myCode/drive/inc/: DRIVE_INCLUDE.h
    ../myCode/drive/src/: hardware.c ws2812.c pwm.c interrupt.c encoder.c mi2c.c d_adc.c d_servo.c
  group BSP
    ../myCode/BSP/inc/: BSP_INCLUDE.h
    ../myCode/BSP/src/: encode_motor.c mRTC.c light_ambient.c power.c servo.c i2c_receive.c
  group myCode
    ../myCode/: myMain.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0
